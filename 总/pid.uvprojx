# Keil uVision project pid.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk,PART_TM4C123GH6PM
  c include: .\driverlib;.\User;.\inc;.\User\oled;.\User\u8g2;..\PID;.\User\pwm;.\User\qei;.\User\usart;.\User\timer;.\User\control;.\User\bsp_debug;.\User\pid;.\User\init;.\User\sys;.\User\key;.\User\beep;.\User\imu901;.\User\openmv;.\User\sensor
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Driverlib
    ./driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Code
    ./User/: main.c
    ./User/oled/: oled.c iic.c
    ./User/pwm/: bsp_pwm.c
    ./User/qei/: bsp_qei.c
    ./User/usart/: bsp_usart.c
    ./User/timer/: bsp_timer.c
    ./User/control/: control.c
    ./User/pid/: data_pid.c
    ./User/bsp_debug/: Fire_protocol.c
    ./User/init/: init.c
    ./User/sys/: bsp_sys.c
    ./User/key/: bsp_key.c
    ./User/beep/: bsp_beep.c
    ./User/imu901/: imu901.c ringbuffer.c
    ./User/openmv/: bsp_openmv.c
    ./User/sensor/: bsp_sensor.c
  group u8g2
    ./User/u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Doc
    ./Doc/: readme.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
